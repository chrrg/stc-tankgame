# Keil uVision project uCosii_51.uvproj, settings and files
target uCOS_II_51 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: uCOS-II +hex
  c flags: Optimize=8
  group user_app
    ./Source/: main.c tankGame.c gameCore.c
    ./User/: STARTUP.A51
  group uCosii
    ./uCosii/: OS_CORE.C OS_CPU_C.C OS_MBOX.C OS_MEM.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C OS_CPU_A.ASM
